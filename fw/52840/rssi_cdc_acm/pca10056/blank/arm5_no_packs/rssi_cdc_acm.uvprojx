# Keil uVision project rssi_cdc_acm.uvprojx, settings and files
target nrf52840_xxaa (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x00800000,0x00040000) IROM(0x00000000,0x00100000) IROM2(0x12000000,0x08000000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: rssi-10056-hephi +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: BOARD_PCA10056 FLOAT_ABI_HARD NRF52840_XXAA SWI_DISABLE0 DEBUG
  c misc: --reduce_paths
  c include: ..\..\..\config;..\..\..\..\sdk\components;..\..\..\..\sdk\components\boards;..\..\..\..\sdk\components\device;..\..\..\..\sdk\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\sdk\components\drivers_nrf\usbd;..\..\..\..\sdk\components\libraries\atomic;..\..\..\..\sdk\components\libraries\atomic_fifo;..\..\..\..\sdk\components\libraries\balloc;..\..\..\..\sdk\components\libraries\bsp;..\..\..\..\sdk\components\libraries\button;..\..\..\..\sdk\components\libraries\delay;..\..\..\..\sdk\components\libraries\experimental_log;..\..\..\..\sdk\components\libraries\experimental_log\src;..\..\..\..\sdk\components\libraries\experimental_memobj;..\..\..\..\sdk\components\libraries\experimental_section_vars;..\..\..\..\sdk\components\libraries\fifo;..\..\..\..\sdk\components\libraries\hardfault;..\..\..\..\sdk\components\libraries\hardfault\nrf52;..\..\..\..\sdk\components\libraries\scheduler;..\..\..\..\sdk\components\libraries\strerror;..\..\..\..\sdk\components\libraries\timer;..\..\..\..\sdk\components\libraries\uart;..\..\..\..\sdk\components\libraries\usbd;..\..\..\..\sdk\components\libraries\usbd\class\cdc;..\..\..\..\sdk\components\libraries\usbd\class\cdc\acm;..\..\..\..\sdk\components\libraries\usbd\config;..\..\..\..\sdk\components\libraries\util;..\..\..;..\..\..\..\sdk\external\fprintf;..\..\..\..\sdk\external\protothreads;..\..\..\..\sdk\external\protothreads\pt-1.4;..\..\..\..\sdk\external\segger_rtt;..\..\..\..\sdk\integration\nrfx;..\..\..\..\sdk\integration\nrfx\legacy;..\..\..\..\sdk\modules\nrfx;..\..\..\..\sdk\modules\nrfx\drivers\include;..\..\..\..\sdk\modules\nrfx\hal;..\..\..\..\sdk\modules\nrfx\mdk;..\config;..\..\..\..\sdk\components\libraries\simple_timer;..\..\..\..\sdk\components\libraries\usbd\class\nrf_dfu_trigger;..\..\..\..\sdk\components\libraries\block_dev;..\..\..\..\sdk\components\libraries\usb_dfu_trigger;..\..\..\..\sdk\components\libraries\bootloader\dfu
  asm define: BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA SWI_DISABLE0
  asm misc: --cpreproc_opts=-DBOARD_PCA10056,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52840_XXAA,-DSWI_DISABLE0
  asm include: ..\..\..\config;..\..\..\..\sdk\components;..\..\..\..\sdk\components\boards;..\..\..\..\sdk\components\device;..\..\..\..\sdk\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\sdk\components\drivers_nrf\usbd;..\..\..\..\sdk\components\libraries\atomic;..\..\..\..\sdk\components\libraries\atomic_fifo;..\..\..\..\sdk\components\libraries\balloc;..\..\..\..\sdk\components\libraries\bsp;..\..\..\..\sdk\components\libraries\button;..\..\..\..\sdk\components\libraries\delay;..\..\..\..\sdk\components\libraries\experimental_log;..\..\..\..\sdk\components\libraries\experimental_log\src;..\..\..\..\sdk\components\libraries\experimental_memobj;..\..\..\..\sdk\components\libraries\experimental_section_vars;..\..\..\..\sdk\components\libraries\fifo;..\..\..\..\sdk\components\libraries\hardfault;..\..\..\..\sdk\components\libraries\hardfault\nrf52;..\..\..\..\sdk\components\libraries\scheduler;..\..\..\..\sdk\components\libraries\strerror;..\..\..\..\sdk\components\libraries\timer;..\..\..\..\sdk\components\libraries\uart;..\..\..\..\sdk\components\libraries\usbd;..\..\..\..\sdk\components\libraries\usbd\class\cdc;..\..\..\..\sdk\components\libraries\usbd\class\cdc\acm;..\..\..\..\sdk\components\libraries\usbd\config;..\..\..\..\sdk\components\libraries\util;..\..\..;..\..\..\..\sdk\external\fprintf;..\..\..\..\sdk\external\protothreads;..\..\..\..\sdk\external\protothreads\pt-1.4;..\..\..\..\sdk\external\segger_rtt;..\..\..\..\sdk\integration\nrfx;..\..\..\..\sdk\integration\nrfx\legacy;..\..\..\..\sdk\modules\nrfx;..\..\..\..\sdk\modules\nrfx\drivers\include;..\..\..\..\sdk\modules\nrfx\hal;..\..\..\..\sdk\modules\nrfx\mdk;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x800000 size 0x40000
  link misc: --diag_suppress 6330
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../sdk/components/boards/: boards.c
  group Board Support
    ../../../../sdk/components/libraries/bsp/: bsp.c bsp_nfc.c
  group nRF_Drivers
    ../../../../sdk/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_power.c nrf_drv_uart.c
    ../../../../sdk/components/drivers_nrf/usbd/: nrf_drv_usbd.c
    ../../../../sdk/components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ../../../../sdk/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_power.c nrfx_power_clock.c nrfx_systick.c nrfx_uart.c nrfx_uarte.c nrfx_timer.c
    ../../../../sdk/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../../../../sdk/components/libraries/button/: app_button.c
    ../../../../sdk/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../sdk/components/libraries/fifo/: app_fifo.c
    ../../../../sdk/components/libraries/scheduler/: app_scheduler.c
    ../../../../sdk/components/libraries/timer/: app_timer.c
    ../../../../sdk/components/libraries/uart/: app_uart_fifo.c
    ../../../../sdk/components/libraries/usbd/: app_usbd.c app_usbd_core.c app_usbd_string_desc.c app_usbd_serial_num.c
    ../../../../sdk/components/libraries/usbd/class/cdc/acm/: app_usbd_cdc_acm.c
    ../../../../sdk/components/libraries/hardfault/nrf52/handler/: hardfault_handler_keil.c
    ../../../../sdk/components/libraries/hardfault/: hardfault_implementation.c
    ../../../../sdk/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../sdk/components/libraries/balloc/: nrf_balloc.c
    ../../../../sdk/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../sdk/components/libraries/experimental_memobj/: nrf_memobj.c
    ../../../../sdk/components/libraries/strerror/: nrf_strerror.c
    ../../../../sdk/components/libraries/simple_timer/: app_simple_timer.c
    ../../../../sdk/components/libraries/usbd/class/nrf_dfu_trigger/: app_usbd_nrf_dfu_trigger.c
    ../../../../sdk/components/libraries/atomic/: nrf_atomic.c
    ../../../../sdk/components/libraries/bootloader/dfu/: nrf_dfu_trigger_usb.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.15.0
